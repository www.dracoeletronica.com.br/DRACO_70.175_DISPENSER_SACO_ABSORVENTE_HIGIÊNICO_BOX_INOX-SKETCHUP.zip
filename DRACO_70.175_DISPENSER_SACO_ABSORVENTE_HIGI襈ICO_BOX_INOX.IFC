Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_70.175_DISPENSER_SACO_ABSORVENTE_HIGIÊNICO_BOX_INOX.IFC
Time: 2023-12-22T12:58:09
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_70.175_2_CHAPA_TRASEIRA_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: DRACO_70.175_CHAPA_FRONTAL_Default
In: Default Storey
Material: AISI 304

# IfcElementAssembly: DRACO_70.175_DISPENSER_SACO_ABSORVENTE_HIGIÊNICO_BOX_INOX
In: Default Storey
PSet_Mass_Property - Mass Measure: 0.24834; Area Measure: 0.0633553 m2; Volume Measure: 0.0000310425 m3
